# Autodesk Inventor assembly: 21.1737 FOOT 90 GD
## iProperties
Created: 2007-04
Part Number: 21.1737 FOOT 90 GD
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
